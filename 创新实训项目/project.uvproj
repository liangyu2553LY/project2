# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c UART.c UART.h wifi_control.c wifi_control.h
  group delay
    ./: delay.c delay.h
  group key
    ./: key.c key.h
  group 12864
    ./: 12864.c 12864.h
  group ds18b20
    ./: ds18b20.c ds18b20.h
